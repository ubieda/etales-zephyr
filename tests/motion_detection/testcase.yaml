## tests/motion_detection/testcase.yaml
```yaml
tests:
  lib.motion_detection:
    platform_allow:
      - qemu_cortex_m3
      - native_sim
```
